Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: fd537934-ce92-4260-a072-d743e1a9a901, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-01T21:07:26+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12135880_PL_WTD280WCS_LW:11TD2801_PL_12135880_WTD280WCS_LW, (2)
In: Default
Type - Material: z_Miele_Design_Cast, z_Miele_Design_Glass, z_Miele_Connection_Gas, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Design_BRWS, <Unnamed>, z_Miele_Connection_Connection_Modul, z_Miele_Connection_Water_IN, z_Miele_Connection_Water_OUT
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 596 mm; Height: 850 mm; Depth: 637 mm
Classification: E1010610 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 11TD2801_PL_12135880_WTD280WCS_LW; sets with these values: 2
